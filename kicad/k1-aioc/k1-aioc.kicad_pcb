# Repository RFnexus/AIOC-no-BC847BS

## KiCad design kicad/k1-aioc/k1-aioc.kicad_pcb

Parts:
C1, C2: 22p/NP0; C_0603_1608Metric; LCSC C1653
C3, C8, C9, C12, C15, C16: 100n; C_0603_1608Metric; LCSC C14663
C4, C5, C6, C7, C10, C13, C14: 4.7u/10V/X5R; C_0603_1608Metric; LCSC C19666
C11: 4.7n/NP0; C_0603_1608Metric; LCSC C53987
D1: GREEN; LED_0603_1608Metric; LCSC C2986059
D2: RED; LED_0603_1608Metric; LCSC C2286
D3, D4: N.M.; LED_0603_1608Metric
FB1, FB2: 600R@100MHz; L_0603_1608Metric; LCSC C1002
H1, H2: ToolingHole; TOOLING-HOLE
J1: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; LCSC C2988369
J2: Conn_01x07_Male; PinHeader_1x07_P1.27mm_Vertical
Q1: MMDT3904; SOT-363_SC-70-6; LCSC C83572
R1, R4, R10, R11, R18, R19: 1.5K; R_0603_1608Metric; LCSC C22843
R2: 4.7K; R_0603_1608Metric; LCSC C23162
R3, R8, R9, R15, R17: 100R; R_0603_1608Metric; LCSC C22775
R5, R6, R7, R14, R16: 5.1K; R_0603_1608Metric; LCSC C23186
R12, R13: 22R; R_0603_1608Metric; LCSC C23345
U1: MIC5332-SSYMT; Micrel_MLF-8-1EP_2x2mm_P0.5mm_EP0.6x1.2mm; LCSC C153276
U2: STM32F373CBTx; LQFP-48_7x7mm_P0.5mm; LCSC C94046
Y1: 8MHz/20pF; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3.3VA: C9.1, C10.1, FB1.1, U2.9 (VDDA), U2.24 (VDDSD), U2.25 (VREFSD+)
+3V3: C4.1, C7.1, C8.1, J2.7, R1.1, U1.8 (VOUT1), U2.1 (VBAT), U2.17 (VDD), U2.36 (PF7), U2.48 (VDD)
/ADC_BIAS: R3.2, U2.16 (PA6)
/AFIN: C11.1, R5.2, R16.2, U2.15 (PA5), U2.20 (PB2)
/AFOUT: R2.2, U2.14 (PA4)
/BOOT0: J2.1, R14.2, U2.44 (BOOT0)
/CC1: J1.A5 (CC1), R7.2
/CC2: J1.B5 (CC2), R6.2
/DAC_ATTEN: C12.1, R17.2, U2.13 (PA3)
/IN1: R19.2, U2.42 (PB6)
/IN2: R18.2, U2.43 (PB7)
/NRST: C15.1, J2.3, U2.7 (NRST)
/OSCIN: C1.1, U2.5 (PF0), Y1.1
/OSCOUT: C2.1, U2.6 (PF1), Y1.2
/OUT1: R11.1, U2.11 (PA1)
/OUT2: R10.1, U2.10 (PA0)
/RADIO-MIC: C13.2
/RADIO-PTT1: R13.1, R19.1
/RADIO-PTT2: R12.1, R18.1
/RADIO-RX: R8.1
/RADIO-SPK: C14.2
/RADIO-TX: R9.1
/SWCLK: J2.6, U2.37 (PA14)
/SWDIO: J2.4, U2.34 (PA13)
/SWO: J2.2, U2.39 (PB3)
/USART-RX: R9.2, U2.31 (PA10)
/USART-TX: R8.2, U2.30 (PA9)
/USB-DN: J1.A7 (D-), J1.B7 (D-), U2.32 (PA11)
/USB-DP: J1.A6 (D+), J1.B6 (D+), R1.2, U2.33 (PA12)
/VBUS: FB2.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
/VIN: C6.1, FB2.1, U1.1 (VIN), U1.4 (EN2), U1.5 (EN1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C15.2, C16.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.5, Q1.1 (E1), Q1.4 (E2), R4.1, R6.1, R7.1, R14.1, U1.2 (GND), U1.9 (GND), U2.8 (VSSA), U2.23 (VSSSD), U2.35 (PF6), U2.47 (VSS)
unnamed: C3.1, U1.3 (POR2)
unnamed: C5.1, FB1.2, U1.7 (VOUT2)
unnamed: C12.2, C13.1, R2.1, R4.2, R17.1
unnamed: C14.1, R5.1
unnamed: C16.2, R3.1, R16.1
unnamed: D1.1 (K), D2.2 (A), D3.1 (K), D4.2 (A), R15.1
unnamed: D1.2 (A), D2.1 (K), D3.2 (A), D4.1 (K), U2.46 (PB9)
unnamed: Q1.2 (B1), R10.2
unnamed: Q1.3 (C2), R13.2
unnamed: Q1.5 (B2), R11.2
unnamed: Q1.6 (C1), R12.2
unnamed: R15.2, U2.45 (PB8)

Notes on the sheet:
STM Disco SWD Header
Short Pins for Bootloader
GPIO Input (5V)
SDADC1_AIN4P/ADC2_IN12
For legacy reasons (V1.0 hardware) PB2 is used when Gain=1 (Input range 0-6.6V) and bias is supplied with static voltage divider For gains x2/x4/x8/x16, OPAMP1 is used. Correct scaled-down ADC bias is supplied via OPAMP2
OPAMP2_VOUT
USART1-TX (5V)
OPAMP1_VINP
K connector consists of two TRS connectors (3.5mm and 2.5mm) spaced 12mm apart Upper connector (2.5mm) T: SPK+ R: TxData (from Radio) S: GND Lower connector (3.5mm) T: +V/PTT2 R: MIC+ S: PTT1/RxData (to Radio) RADIO-RX and RADIO-PTT1 have a split-pad in the layout, which is automatically connected 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
GPIOA P.P.
DAC1_OUT1
GPIOA O.D.
Compatible to STM32F302CBTx (no DS-ADC)
Maximum DAC Load 5Kohm Output Level 350mVpk @ 10Kohm load Output impedance approx. 1.3Kohm With Attenuator: Output Level 35mVpk Output impedance approx. 90Ohm
USART1-RX (5V)
U1: MIC5332-SSYMT (LCSC C153276) is a drop-in for the unobtainable MIC5330-SSYML. Pin 3 = POR2 (open-drain reset output, unused; C3 is harmless). Pin 6 = CSET2: leave OPEN, never connect to GND.

Board: 2 copper layers, 21.0 x 31.5 mm, 49 parts (2 on the bottom side), 40 nets.

File kicad/k1-aioc/jlcpcb/production_files/BOM-k1-aioc.csv:

Comment,Designator,Footprint,LCSC
600R@100MHz,"FB1,FB2",L_0603_1608Metric,C1002
8MHz/20pF,Y1,Crystal_SMD_5032-2Pin_5.0x3.2mm,C115962
MIC5332-SSYMT,U1,Micrel_MLF-8-1EP_2x2mm_P0.5mm_EP0.6x1.2mm,C153276
100n,"C12,C15,C16,C3,C8,C9",C_0603_1608Metric,C14663
22p/NP0,"C1,C2",C_0603_1608Metric,C1653
4.7u/10V/X5R,"C10,C13,C14,C4,C5,C6,C7",C_0603_1608Metric,C19666
100R,"R15,R17,R3,R8,R9",R_0603_1608Metric,C22775
1.5K,"R1,R10,R11,R18,R19,R4",R_0603_1608Metric,C22843
RED,D2,LED_0603_1608Metric,C2286
4.7K,R2,R_0603_1608Metric,C23162
5.1K,"R14,R16,R5,R6,R7",R_0603_1608Metric,C23186
22R,"R12,R13",R_0603_1608Metric,C23345
USB4105-GF-A,J1,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,C2988369
4.7n/NP0,C11,C_0603_1608Metric,C53987
GREEN,D1,LED_0603_1608Metric,C2986059
MMDT3904,Q1,SOT-363_SC-70-6,C83572
STM32F373CBTx,U2,LQFP-48_7x7mm_P0.5mm,C94046
Conn_01x07_Male,J2,PinHeader_1x07_P1.27mm_Vertical,
N.M.,D4,LED_0603_1608Metric,
N.M.,D3,LED_0603_1608Metric,
